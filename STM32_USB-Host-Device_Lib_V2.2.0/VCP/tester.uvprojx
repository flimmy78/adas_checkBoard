# Keil uVision project tester.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tester +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o tester.bin .\objects\tester.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_USB_OTG_FS  USE_EMBEDDED_PHY STM32F10X_CL
  c include: .\inc;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32_USB_Device_Library\Core\inc;..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32_USB_Device_Library\Class\cdc\inc;..\Libraries\STM32_USB_OTG_Driver\inc;.\src\FreeRTOS\Source\include;.\src\FreeRTOS\Source\portable\RVDS\ARM_CM3;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\test.sct
  group usb_lib
    ../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_dcd.c usb_core.c usb_dcd_int.c
    ../Libraries/STM32_USB_Device_Library/Core/src/: usbd_req.c usbd_core.c usbd_ioreq.c
  group src
    ./src/: stm32fxxx_it.c startup_stm32f10x_cl.s system_stm32f10x.c usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c driver.c can.c crc32.c fifo8.c main.c adc.c trace.c INA226.c soft_i2c.c usb_comm.c test.c firm.c
  group stdlib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS9.0
    ./src/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ./src/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ./src/FreeRTOS/Source/portable/MemMang/: heap_3.c
